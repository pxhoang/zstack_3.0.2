# IAR project ZNP.ewp, settings and files
configuration CC2538ZNP-Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: HAL_UART_USB; USB_SETUP_MAX_NUMBER_OF_INTERFACES=5; xHAL_SPI=TRUE; xHAL_UART=TRUE; BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; DISABLE_GREENPOWER_BASIC_PROXY; TC_LINKKEY_JOIN; ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; CC2538ZNP; ZNP_ALT; xPOWER_SAVING; FEATURE_SYSTEM_STATS; FEATURE_RESET_MACRO; ZDNWKMGR_MIN_TRANSMISSIONS=0; MT_UART_DEFAULT_OVERFLOW=FALSE; ASSERT_RESET; FAKE_CRC_SHDW; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050, Pe826, Pe236
  ICCARM.IExtraOptions: -f ..\Source\znp.cfg; -f ..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\Tools\CC2538DB\f8wZCL.cfg
  ICCARM.CCIncludePath2: $PROJ_DIR$; Source; ..\Source; ..\..\SE\Source; ..\..\ZMain\TI2538ZNP; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\_common\cc2538; ..\..\..\..\Components\hal\target\CC2538ZNP; ..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\Components\mac\include; ..\..\..\..\Components\mac\high_level; ..\..\..\..\Components\mac\low_level\srf05; ..\..\..\..\Components\mac\low_level\srf05\single_chip; ..\..\..\..\Components\mt; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\ecc\binary163; ..\..\..\..\Components\services\ecc\binary283; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\services\sdata; ..\..\..\..\Components\stack\af; ..\..\..\..\Components\stack\bdb; ..\..\..\..\Components\stack\GP; ..\..\..\..\Components\stack\nwk; ..\..\..\..\Components\stack\sapi; ..\..\..\..\Components\stack\sec; ..\..\..\..\Components\stack\sys; ..\..\..\..\Components\stack\zcl; ..\..\..\..\Components\stack\zdo; ..\..\..\..\Components\zmac; ..\..\..\..\Components\zmac\f8w; ..\..\..\..\Components\osal\mcu\cc2538; ..\..\..\..\Components\usblib\cc2538\source\library; ..\..\..\..\Components\usblib\cc2538\source\library\cc2538; ..\..\..\..\Components\usblib\cc2538\source; ..\..\..\..\Components\usblib\cc2538\source\class_cdc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: ZNP.bin
  ILINK.IlinkOutputFile: ZNP.out
  ILINK.IlinkIcfFile: ..\..\Tools\CC2538DB\CC2538.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkAdditionalLibs: bsp_no_lcd_buf.lib; ..\..\Libraries\CC2538\bin\Ecc.a; ..\..\Libraries\CC2538\bin\AllDevice.a; ..\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\Components\usblib\cc2538\bin\iar\usbcdc.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CC2538ZNP-with-SBL (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: xHAL_UART_USB; xUSB_SETUP_MAX_NUMBER_OF_INTERFACES=5; xHAL_SPI=TRUE; HAL_UART=TRUE; BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; DISABLE_GREENPOWER_BASIC_PROXY; TC_LINKKEY_JOIN; ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; CC2538ZNP; ZNP_ALT; xPOWER_SAVING; FEATURE_SYSTEM_STATS; FEATURE_RESET_MACRO; ZDNWKMGR_MIN_TRANSMISSIONS=0; MT_UART_DEFAULT_OVERFLOW=FALSE; ASSERT_RESET; MAKE_CRC_SHDW; SBL_CLIENT; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC
  postbuild: "..\tools\znp.bat" "..\tools" "CC2538ZNP-with-SBL"
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ..\..\Tools\CC2538DB\CC2538-sb.icf
configuration CC2538ZNP-without-SBL (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; FEATURE_SYSTEM_STATS; xPOWER_SAVING; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; CC2538ZNP; FEATURE_RESET_MACRO; ASSERT_RESET; FAKE_CRC_SHDW; ZDNWKMGR_MIN_TRANSMISSIONS=0; xHAL_UART_USB; xHAL_SPI=TRUE; HAL_UART=TRUE; xZNP_ALT; MT_UART_DEFAULT_OVERFLOW=FALSE; xUSB_SETUP_MAX_NUMBER_OF_INTERFACES=5; TC_LINKKEY_JOIN; HAL_PA_LNA; HAL_PA_LNA_CC2592; BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_DISCOVER; DISABLE_GREENPOWER_BASIC_PROXY; TP2_LEGACY_ZC; SBL_CLIENT; INCLUDE_REVISION_INFORMATION; MT_SYS_KEY_MANAGEMENT=1
  OBJCOPY.OOCOutputFile: dev\CC2538ZNP-without-SBL.bin
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: ..\..\Tools\CC2538DB\CC2538-sb.icf
  group Application
    ../Source/: OSAL_ZNP.c znp_app.c znp_app.h znp_spi.h
    Source/: znp_soc.c znp_spi.c
  group BDB
    ../../../../Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    ../../../../Components/stack/GP/: cGP_stub.h dGP_stub.h gp_common.c gp_common.h gp_interface.h gp_proxyTbl.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2538ZNP/Config
    ../../../../Components/hal/target/CC2538ZNP/: hal_board_cfg.h
  group HAL/Target/CC2538ZNP/Drivers
    ../../../../Components/hal/target/CC2538ZNP/: hal_adc.c hal_aes.c hal_ccm.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_spi.c hal_sys_ctrl.c hal_systick.c hal_uart.c startup_ewarm.c
  group HAL/Target/CC2538ZNP/Includes
    ../../../../Components/hal/target/CC2538ZNP/: hal_aes.h hal_ccm.h hal_mcu.h hal_spi.h hal_types.h
  group MAC/High Level
    ../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../Components/mac/low_level/srf05/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group MT
    ../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h MT_ZNP.c MT_ZNP.h
  group NWK
    ../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../Components/osal/mcu/cc2538/: armcm3flashutil.c osal_nv.c
    ../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Profile
    ../../../../Components/stack/af/: AF.c AF.h
    ../../../../Components/stack/sapi/: sapi.c sapi.h
    ../../../../Components/stack/zcl/: zcl.c zcl.h zcl_green_power.c zcl_green_power.h zcl_key_establish.c zcl_key_establish.h
  group Security
    ../../../../Components/stack/sec/: eccapi.h ssp.h ssp_hash.h
  group Services
    ../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../Tools/CC2538DB/: f8wConfig.cfg f8wZCL.cfg
    ../Source/: znp.cfg
  group ZDO
    ../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../ZMain/TI2538ZNP/: OnBoard.c OnBoard.h ZMain.c
